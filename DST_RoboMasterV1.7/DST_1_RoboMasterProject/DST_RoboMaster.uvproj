# Keil uVision project DST_RoboMaster.uvproj, settings and files
target DST_RoboMaster (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: DST_RoboMaster +hex
  c flags: Optim=1
  c define: STM32F40XX, USE_STDPERIPH_DRIVER
  c misc: --cpp
  c include: ..\STM32F4_CORE;..\STM32F4_FWLIB\inc;..\DST_1_RoboMasterProject;..\DST_2_Notes;..\DST_3_RoboMasterConfig;..\DST_4_HardwareDrivers;..\DST_5_PIDControl;..\DST_6_DataProcess;..\DST_7_MathClass
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group DST_1_RoboMasterMain
    ./: DST_RoboMaster_Main.cpp stm32f4xx_it.c
  group DST_2_Notes
    ../DST_2_Notes/: DST_Notes.c
  group DST_3_RoboMasterConfig
    ../DST_3_RoboMasterConfig/: DST_RoboMasterConfig.h DST_RoboMasterInclude.h
  group DST_4_HardwareDrivers
    ../DST_4_HardwareDrivers/: DST_HardwarePinConfig.h DST_HardwareInit.cpp DST_HardwareInit.h DST_SysTimer.cpp DST_SysTimer.h DST_LED.cpp DST_LED.h DST_CAN_1.cpp DST_CAN_1.h DST_CAN_2.cpp DST_CAN_2.h DST_DBUS_USART2.cpp DST_DBUS_USART2.h DST_IIC_Soft.cpp DST_IIC_Soft.h DST_MPU6050.cpp DST_MPU6050.h DST_PWMOUT.cpp DST_PWMOUT.h
  group DST_5_PIDControl
    ../DST_5_PIDControl/: DST_GimbleControl.cpp DST_GimbleControl.h DST_PID.cpp DST_PID.h
  group DST_6_DataProcess
    ../DST_6_DataProcess/: DST_DataProcess.cpp DST_DataProcess.h
  group DST_7_MathClass
    ../DST_7_MathClass/: DST_Math.cpp DST_Math.h DST_AmplitudeLimit.cpp DST_AmplitudeLimit.h DST_Vector3.h DST_Quaternion.cpp DST_Quaternion.h
  group STM32F4_CORE
    ../STM32F4_CORE/: startup_stm32f40_41xxx.s
  group STM32F4_FWLIB
    ./: system_stm32f4xx.c stm32f4xx.h stm32f4xx_it.h stm32f4xx_conf.h
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_flash.c
